Commit message: chore : changed the finger joint motion to x axis instead of y-axis

File: URDF/lite-6/lite_6.urdf (robot description, URDF)
Before this commit: robot lite6, 11 links, 10 joints
Joints:
- joint left_finger_joint: axis 0 1 0 -> -1 0 0
- joint right_finger_joint: axis 0 -1 0 -> 1 0 0
